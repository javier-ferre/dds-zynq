SRC_URI += "file://user_2021-07-21-22-52-00.cfg \
            file://user_2021-07-21-23-18-00.cfg \
            file://user_2021-07-22-22-04-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

